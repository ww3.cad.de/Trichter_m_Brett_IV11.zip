# Autodesk Inventor assembly: Trichter_m_Brett
## iProperties
Created: 2010-01
Part Number: Trichter_m_Brett
Document SubType Name: Assembly
Author: Winsemann
