# Autodesk Inventor part: Brett
## iProperties
Created: 2010-01
Part Number: Brett
Material: 1.4301
Document SubType Name: Modeling
Author: Winsemann
## Feature names
1. Extrusion1
2. Extrusion4
