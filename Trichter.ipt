# Autodesk Inventor part: Trichter
## iProperties
Created: 2010-01
Part Number: Trichter
Material: 1.4301
Document SubType Name: Modeling
Author: Winsemann
## Feature names
1. Drehung1 [Revolution]
